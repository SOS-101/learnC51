# Keil uVision project template.uvproj, settings and files
target project (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: template +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./: main.c XPT2046.c
