# Keil uVision project template.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89C51RC Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM(0-0xFF) CLOCK(33000000) MODP2
  output: template +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: STARTUP.A51 main.c
